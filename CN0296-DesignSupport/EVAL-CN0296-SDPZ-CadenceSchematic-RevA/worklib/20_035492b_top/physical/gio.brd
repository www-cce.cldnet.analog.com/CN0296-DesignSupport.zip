# Allegro board gio.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
UNNAMED_4_CAP4PV3_I13_IN on TOP: 20.19,11.94 24.51,11.94 24.51,9.53 23.5,8.51 20.57,8.51 20.57,9.65 20.19,10.03
UNNAMED_4_CAP4PV3_I13_OUT on TOP: 23.5,15.88 24.77,15.88 24.77,13.59 24.64,13.46 23.62,13.46 23.5,13.59
UNNAMED_4_CAP_I6_N1 on TOP: 13.46,13.21 13.46,14.48 15.37,16.38 21.21,16.38 21.84,15.75 21.84,13.46 19.68,13.46 19.3,13.08 17.27,13.08 17.27,10.67 16,10.67

## Text on the board
Ref Des/Silkscreen Top: GND | VIN | IOVDD | SDATA | BCLK | LRCLK | MCLK | OUTR4 | OUTL4 | OUTR3 | OUTL3 | OUTR2 | OUTL2 | OUTR1 | OUTL1 | REV A | EVAL-CN0296-SDPZ
DIMENSION: REF
PAGE_OUTLINE: J. CHUA | 11DEC12 | N/A | ADAU1761 & SSM2518
DISPLAY_BOTTOM: L2 DGND | 08-      -07
User.6: L3 PWR | 08-      -08
User.7: ROHS COMPLIANCE NOTE:  (Required for Customer Boards) Add to top of MATERIALS | 100 MICRO INCHES NICKEL/ | 3-5 MICRO INCHES GOLD | HOMOGENOUS MATERIALS IN THIS BOARD SHALL BE COMPLIANT | THE EU RoHS DIRECTIVE 2002/95/EC | 50 OHMS SINGLE ENDED, 15 MILS LINE
User.11: L4 SIG
User.12: L5 PWR
User.21: FIGURE | SIZE | 12.0 | 35.0 | 40.0 | 45.0 | 63.0 | 120.0 | 140.0 | 28.0 | 43.0 | 67.0 | 125.0 | 136.0 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILS | TOLERANCE | +3.0/-3.0 | +2.0/-2.0 | PLATED | NON-PLATED | QTY | 448 | 2 | 38 | 11 | 1 | 14 | 4 | 3
