# Allegro board 20_035492b.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
VIN on TOP: 34.92,27.3 33.97,27.3 33.97,26.67 32.51,26.67 32.51,21.27 39.37,21.27 39.37,26.67 37.78,26.67 37.78,27.3 36.83,27.3 36.83,26.04 38.42,26.04 38.42,22.86 33.34,22.86 33.34,26.04 34.92,26.04
VIN on TOP: 60.96,27.3 60.01,27.3 60.01,26.67 58.42,26.67 58.42,21.27 65.41,21.27 65.41,26.67 63.82,26.67 63.82,27.3 62.86,27.3 62.86,26.04 64.45,26.04 64.45,22.86 59.37,22.86 59.37,26.04 60.96,26.04
VIN on TOP: 3.17,61.47 24.64,82.93 41.02,82.93 47.62,89.53 47.88,89.53 48.01,89.41 48.01,88.9 40,80.9 32.51,80.9 16.38,64.77 16.38,49.66 14.48,49.66 14.48,48.77 16.38,48.77 16.38,47.75 12.7,47.75 12.45,48.01 12.45,49.78 12.07,50.16 9.78,50.16 8.89,49.28 8.89,42.93 12.45,39.37 15.75,39.37 15.75,38.73 12.95,38.73 12.95,37.47 15.75,37.47 15.75,36.83 11.81,36.83 11.81,38.23 11.56,38.48 9.4,38.48 8.76,37.85 8.76,36.2 11.3,33.66 14.22,33.66 14.22,30.23 24.77,19.69 24.77,17.02 16.64,17.02 3.17,30.48
VIN on L3_PWR: 6.35,0.64 6.35,6.35 1.27,6.35 1.27,33.02 17.14,33.02 17.14,27.94 92.71,27.94 92.71,6.35 87.63,6.35 87.63,0.64
IOVDD on TOP: 16.64,38.73 18.41,38.73 18.67,38.48 18.67,34.8 19.81,33.66 22.61,33.66 23.62,34.67 23.62,37.59 22.86,38.35 20.83,38.35 20.57,38.61 20.57,42.55 19.43,42.55 19.43,40.51 18.29,39.37 16.64,39.37
IOVDD on TOP: 80.65,34.54 80.65,31.5 83.19,31.5 83.19,34.54
IOVDD on TOP: 67.06,34.61 70.55,34.61 70.55,30.48 71.5,29.53 72.45,29.53 72.52,29.46 72.52,28.7 70.99,28.7 67.06,32.64
IOVDD on TOP: 54.99,34.61 58.42,34.61 58.42,30.48 59.37,29.53 60.32,29.53 60.32,28.7 58.8,28.7 54.99,32.51
IOVDD on TOP: 41.91,31.75 41.91,34.61 45.4,34.61 45.4,30.48 46.35,29.53 47.31,29.53 47.31,29.46 47.37,29.46 47.37,28.7 44.96,28.7
IOVDD on TOP: 34.29,29.53 34.29,28.7 31.88,28.7 28.96,31.62 28.96,31.69 28.89,31.75 28.89,34.61 32.38,34.61 32.38,30.48 33.34,29.53
IOVDD on L3_PWR: 18.41,29.21 18.41,34.29 1.27,34.29 1.27,85.09 6.99,85.09 6.99,91.44 1.27,91.44 1.27,92.71 92.71,92.71 92.71,92.08 86.36,92.08 86.36,83.82 92.71,83.82 92.71,29.21 ; 3 cut-outs
UNNAMED_4_CAP4PV3_I13_IN on TOP: 20.19,11.94 24.51,11.94 24.51,9.53 23.5,8.51 20.57,8.51 20.57,9.65 20.19,10.03
UNNAMED_4_CAP4PV3_I13_OUT on TOP: 23.5,15.88 24.77,15.88 24.77,13.59 24.64,13.46 23.62,13.46 23.5,13.59
UNNAMED_4_CAP_I6_N1 on TOP: 13.46,13.21 13.46,14.48 15.37,16.38 21.21,16.38 21.84,15.75 21.84,13.46 19.68,13.46 19.3,13.08 17.27,13.08 17.27,10.67 16,10.67

## Text on the board
Ref Des/Silkscreen Top: GND | VIN | IOVDD | SDATA | BCLK | LRCLK | MCLK | OUTR4 | OUTL4 | OUTR3 | OUTL3 | OUTR2 | OUTL2 | OUTR1 | OUTL1 | REV B | EVAL-CN0296-SDPZ
DIMENSION: REF
PAGE_OUTLINE: J. CHUA | 11DEC12 | N/A | ADAU1761 & SSM2518
DISPLAY_BOTTOM: L2 DGND | 08-      -07
User.6: L3 PWR | 08-      -08
User.7: ROHS COMPLIANCE NOTE:  (Required for Customer Boards) Add to top of MATERIALS | 100 MICRO INCHES NICKEL/ | 3-5 MICRO INCHES GOLD | HOMOGENOUS MATERIALS IN THIS BOARD SHALL BE COMPLIANT | THE EU RoHS DIRECTIVE 2002/95/EC | 50 OHMS SINGLE ENDED, 15 MILS LINE
User.11: L4 SIG
User.12: L5 PWR
User.21: FIGURE | SIZE | 12.0 | 35.0 | 40.0 | 45.0 | 63.0 | 120.0 | 140.0 | 28.0 | 43.0 | 67.0 | 125.0 | 136.0 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILS | TOLERANCE | +3.0/-3.0 | +2.0/-2.0 | PLATED | NON-PLATED | QTY | 443 | 2 | 38 | 10 | 14 | 1 | 4 | 3
